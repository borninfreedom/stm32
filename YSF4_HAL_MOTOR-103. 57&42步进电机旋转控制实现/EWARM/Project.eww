<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\YS-F4Pro.ewp</path>
  </project>
  <batchBuild />
</workspace>
